# Keil uVision project STM32+UCOSII.uvprojx, settings and files
target STM32_UCOSII (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32+UCOSII
  c flags: Optim=1 oTime=1
  c include: ..\APP;..\BSP;..\CMSIS;..\StdPeriph_Driver\inc;..\uCOS-II\Ports;..\uCOS-II\Source;..\USER;..\FATFS_V0.09\src;..\FATFS_V0.09\src\option;..\BSP\SPI_SD_Card;..\BSP\ENC28J60;..\BSP\TIMER;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\lwip_comm;..\MALLOC;..\LWIP\lwip_app\tcp_client_demo;..\APP\AM2305;..\BSP\PTO;..\BSP\encoder
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../APP/: app.c taskSR04.c taskCommunication.c taskRTC.c taskMSD.c taskLIFT.c taskStepMotor.c app_cfg.h os_cfg.h
    ../APP/AM2305/: task2305.c
  group BSP
    ../BSP/: BSP.C usart.c SR04.c adc.c rtc.c fatfs.c AM2305.c bsp_cfg.h
    ../BSP/SPI_SD_Card/: SPI_MSD0_Driver.c
    ../BSP/ENC28J60/: enc28j60.c
    ../BSP/PTO/: pto.c
    ../BSP/encoder/: encoder.c
    ../BSP/TIMER/: timerx.c
  group USER
    ../USER/: main.c stm32f10x_it.c
  group StartUP
    ../CMSIS/RVMDK/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriph_Driver
    ../StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_spi.c
  group uCOS-II\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group FatFS
    ../FATFS_V0.09/src/option/: ccsbcs.c
    ../FATFS_V0.09/src/: diskio.c ff.c
  group 说明
    ../: 函数说明.txt 模板说明.txt
